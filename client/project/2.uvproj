# Keil uVision project 2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ADC.c delay.c Keypress.c main.c oled.c SYN6288.C USART.C
